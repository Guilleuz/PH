# Keil uVision project sudoku_2021.uvproj, settings and files
target LPC2105 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: sudoku_2021
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Assembly
    ./: Startup.s candidatos_actualizar_arm_c.s candidatos_propagar_arm.s candidatos_actualizar_arm.s reiniciarPLL.s
  group Includes
    ./: celda.h tableros.h cola.h eventos.h gestor_alarmas.h gestor_energia.h gestor_io.h gestor_pulsacion.h timer0.h timer1.h
  group Sources
    ./: sudoku_2021.c cola.c gestor_alarmas.c gestor_energia.c gestor_io.c gestor_pulsacion.c timer0.c timer1.c
